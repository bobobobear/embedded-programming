# Keil uVision project lab4.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Lab4 +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\LibraryFiles\LibraryFiles\CORE;.\LibraryFiles\LibraryFiles\FreeRTOS\include;.\LibraryFiles\LibraryFiles\FreeRTOS\portable\RVDS\ARM_CM3;.\LibraryFiles\LibraryFiles\HARDWARE\LED;.\LibraryFiles\LibraryFiles\HARDWARE\OLED;.\LibraryFiles\LibraryFiles\STM32F1xx_Driver\src;.\LibraryFiles\LibraryFiles\STM32F1xx_Driver\inc;.\LibraryFiles\LibraryFiles\SYSTEM\delay;.\LibraryFiles\LibraryFiles\SYSTEM\show;.\LibraryFiles\LibraryFiles\SYSTEM\sys;.\LibraryFiles\LibraryFiles\SYSTEM\SYSTEM;.\LibraryFiles\LibraryFiles\HARDWARE\BUZZ;.\LibraryFiles\LibraryFiles\HARDWARE\UART;.\LibraryFiles\LibraryFiles\HARDWARE\BUTTON
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group CORE
    ./LibraryFiles/LibraryFiles/CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group FreeRTOS
    ./LibraryFiles/LibraryFiles/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./LibraryFiles/LibraryFiles/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./LibraryFiles/LibraryFiles/FreeRTOS/portable/MemMang/: heap_4.c
  group SYSTEM
    ./LibraryFiles/LibraryFiles/SYSTEM/sys/: sys.c
    ./LibraryFiles/LibraryFiles/SYSTEM/SYSTEM/: system.c
    ./LibraryFiles/LibraryFiles/SYSTEM/delay/: delay.c
    ./LibraryFiles/LibraryFiles/SYSTEM/show/: show.c
  group HARDWARE
    ./LibraryFiles/LibraryFiles/HARDWARE/LED/: LED.C
    ./LibraryFiles/LibraryFiles/HARDWARE/OLED/: oled.c
    ./LibraryFiles/LibraryFiles/HARDWARE/BUZZ/: BUZZ.c
    ./LibraryFiles/LibraryFiles/HARDWARE/UART/: UART.c UART.h
    ./LibraryFiles/LibraryFiles/HARDWARE/BUTTON/: BUTTON.c BUTTON.h
  group STM32F1xx_Driver
    ./LibraryFiles/LibraryFiles/STM32F1xx_Driver/src/: stm32f10x_gpio.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Main
    ./: main.c
