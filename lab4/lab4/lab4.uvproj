# Keil uVision project lab4.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lab4 +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\LibraryFiles\CORE;.\LibraryFiles\STM32F1xx_Driver\inc;.\LibraryFiles\FreeRTOS\include;.\LibraryFiles\FreeRTOS\portable\RVDS\ARM_CM3;.\LibraryFiles\SYSTEM\sys;.\LibraryFiles\SYSTEM\delay;.\LibraryFiles\SYSTEM\show;.\LibraryFiles\SYSTEM\SYSTEM;.\LibraryFiles\SYSTEM\usart;.\LibraryFiles\HARDWARE\IIC;.\LibraryFiles\HARDWARE\LED;.\LibraryFiles\HARDWARE\MPU9250;.\LibraryFiles\HARDWARE\OLED;.\LibraryFiles\HARDWARE\Buzzer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ./: startup_stm32f10x_hd.s
    ./LibraryFiles/CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group FreeRTOS
    ./LibraryFiles/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./LibraryFiles/FreeRTOS/portable/MemMang/: heap_4.c
    ./LibraryFiles/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group HARDWARE
    ./LibraryFiles/HARDWARE/IIC/: IOI2C.c
    ./LibraryFiles/HARDWARE/LED/: LED.C
    ./LibraryFiles/HARDWARE/MPU9250/: mpu9250.c
    ./LibraryFiles/HARDWARE/OLED/: oled.c
    ./LibraryFiles/HARDWARE/Buzzer/: buzzer.c
  group STM32F1xx_Driver
    ./LibraryFiles/STM32F1xx_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ./LibraryFiles/SYSTEM/delay/: delay.c
    ./LibraryFiles/SYSTEM/show/: show.c
    ./LibraryFiles/SYSTEM/sys/: sys.c
    ./LibraryFiles/SYSTEM/SYSTEM/: system.c
    ./LibraryFiles/SYSTEM/usart/: usart.c
  group main
    ./: main.c
